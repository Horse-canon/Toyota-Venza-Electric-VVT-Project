# Keil uVision project Fortior_FOC_FU68x6.uvproj, settings and files
target Fortior_FOC_FU68x6 (MCS-51)
  device: FU6866 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: Fortior_FOC_FU68x6 +hex
  c flags: Optimize=9
  c include: ..\User\include;..\FU68xx_Hardware_Driver\Include;.\Components
  asm include: ..\User\include;..\FU68xx_Hardware_Driver\Include
  link misc: REMOVEUNUSED
  group Application
    ../User/source/Application/: main.c AddFunction.c Interrupt.c
    ../User/include/: Customer.h Protect.h Parameter.h
  group Function
    ../User/source/Function/: MotorControl.c MotorControlFunction.c MotorProtect.c SLEEP.c HALL_V0.c HallProcess.c SeatFun.c AntiPinch.c
  group HardWare
    ../User/source/Hardware/: ADC.c AMP.c CMP.c CRC.c DMA.c DRIVER.c GPIO.c I2C.c PIInit.c SPI.c TIMER.c UART.c TSD.c SMDU.c Lin.c FU68xx_6_Flash.c
  group FU68XX_Hardware_Driver
    ../FU68xx_Hardware_Driver/Source/: STARTUP_FU6816.A51
  group Document
    ../: README.md
  group Components
    ./Components/: OnChipFlash.c CAN.c CANIF.c
